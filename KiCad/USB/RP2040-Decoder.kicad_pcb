# Repository gab-k/RP2040-Decoder

File README.md:

# RP2040-Decoder

Designed to be a low-cost, open-source alternative to commercial DCC decoders, it utilizes the Raspberry Pi RP2040 dual-core microcontroller. The decoder features DCC protocol decoding and command interpretation alongside motor control in a compact 25x20 mm form factor.

## Key Features
*   **DCC Signal Decoding**: Interrupt-based edge detection with full packet/protocol decoding.
*   **Motor Control**: 128 speed steps with configurable acceleration/deceleration ramping and v_min/v_mid/v_max; closed-loop control for consistent motor speed under varying load conditions.
*   **Flexible I/O**: 4x transistor-switched outputs and 6x additional GPIOs; all of them PWM capable.
*   **CV Configuration**: Function mapping and programming track support.
*   **Standards Compliance**: Implements the most important NMRA (S-9.1, S-9.2.x) and RCN (210, 212, 216) DCC standards.
*   **Compact Form Factor**: 25x20 mm board size.
*   **Integrated Documentation**: Comprehensive [GitHub Pages documentation](https://gab-k.github.io/RP2040-Decoder/) covering hardware theory and software implementation.

## Architecture Overview
The system uses each of the two ARM Cortex-M0+ cores for separate tasks:

*   **Core 0: Signal Processing & Management**
    *   DCC edge detection and packet decoding.
    *   Configuration Variable (CV) management using persistent flash storage.
    *   Service Mode (Programming Track) logic and acknowledgment pulse generation.
*   **Core 1: Motion Control**
    *   **PID Controller**: A discrete-time PID motor controller implementation utilizing based on a bilinear transform formula.
    *   **Back-EMF Feedback**: ADC sampling during PWM-off cycles.
    *   **Adaptive Control**: Gain scheduling for $K_P$ and a startup controller (feed-forward) to overcome static friction.

## Hardware Revisions

### USB Version
Optimized for ease of use; supports UF2 drag-and-drop flashing and serial logging.
<div style="display: flex; gap: 10px;">

</div>

### Legacy Version
Revision without USB, one sided assembly, flashed via SWD.
<div style="display: flex; gap: 10px;">

</div>

## Getting Started

To get started, you will first need the hardware. The different options for acquiring a board are outlined [here](https://gab-k.github.io/RP2040-Decoder/sphinx/html/gs/getting_started.html#where-to-get-the-board).

For the software, you have a few options: you can either [build it from source](https://gab-k.github.io/RP2040-Decoder/sphinx/html/gs/getting_started.html#building-the-software) or use the ready-to-flash [binaries built by the CI pipeline](https://github.com/gab-k/RP2040-Decoder/releases) on each release. [Flashing the firmware](https://gab-k.github.io/RP2040-Decoder/sphinx/html/gs/getting_started.html#flashing-the-software) can be done via SWD or, if you are using the USB hardware version, simply by dragging and dropping the file using your regular file explorer.

## License

*   **Software**: MIT License
*   **Hardware**: CERN Open Hardware Licence Version 2 - Permissive

## KiCad design KiCad/USB/RP2040-Decoder.kicad_pcb

Parts:
C1, C4: 10p; C_0402_1005Metric; Voltage 25V; LCSC Part # C32949
C2, C10, C11, C12, C14, C15, C16: 100n; C_0402_1005Metric; Voltage 6V3; LCSC Part # C1525
C3: 10u; C_0603_1608Metric; Voltage 6V3; LCSC Part # C96446
C5, C17, C18: 10u; C_0603_1608Metric; Voltage 25V; LCSC Part # C96446
C6, C7: 100n; C_0402_1005Metric; Voltage 2V5; LCSC Part # C1525
C8: 10u; C_0402_1005Metric; Voltage 2V5; LCSC Part # C15525
C9, C13: 10u; C_0402_1005Metric; Voltage 6V3; LCSC Part # C15525
D1: 1N5819WS; D_SOD-323_HandSoldering; LCSC Part # C191023
D2: KMB24F; TO-269AA; LCSC Part # C880910
D3: LED; LED_0603_1608Metric; LCSC Part # C2286
J1, J2, J4, J14, J15, J16, J17, J18, J21: Conn_01x01; TestPoint_Pad_D2.0mm
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; LCSC Part # C2927038
J5, J6, J7, J8, J9, J10, J11, J12, J13: Conn_01x01; TestPoint_Pad_D1.5mm
J19, J20: Conn_01x01; TestPoint_Pad_1.5x1.5mm
Q1, Q2, Q3, Q4, Q5: Si1308EDL; SOT-323_SC-70; LCSC Part # C469327
R1: DNF; R_0402_1005Metric; not fitted
R2, R3: 5k1; R_0402_1005Metric; Tolerance 1%; LCSC Part # C25905
R4, R10: 1k; R_0402_1005Metric; Tolerance 10%; LCSC Part # C11702
R5, R13, R15: 1k; R_0402_1005Metric; Tolerance 1%; LCSC Part # C11702
R6, R7: 27; R_0402_1005Metric; Tolerance 1%; LCSC Part # C138021
R8, R9: 6k8; R_0402_1005Metric; Tolerance 10%; LCSC Part # C25917
R11: 200; R_0402_1005Metric; Tolerance 1%; LCSC Part # C25087
R12, R14: 6k8; R_0402_1005Metric; Tolerance 1%; LCSC Part # C25917
SW1: YTS1T0162AWJ00; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816; LCSC Part # C3726363
U1: MIC5200-3.3YS; SOT-223; LCSC Part # C5343216
U2: W25Q64JVSSIQ; SOIC-8_5.23x5.23mm_P1.27mm; LCSC Part # C179171
U3: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; LCSC Part # C2040
U4: BDR6133; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias; LCSC Part # C2687793
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC Part # C9002

Connections:
+1V1: C6.1, C7.1, C8.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C2.1, C3.1, C9.1, C10.1, C11.1, C12.1, C14.1, C15.1, C16.1, C18.1, J4.1, R1.2, R11.1, U1.3 (VOUT), U2.8 (VCC), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.2 (VCC)
/ADC_EMF_A: R12.1, R13.2, U3.41 (GPIO29_ADC3)
/ADC_EMF_B: R14.1, R15.2, U3.40 (GPIO28_ADC2)
/GPIO21: Q1.3 (D), U3.32 (GPIO21)
/GPIO22: U3.34 (GPIO22), U4.7 (INB)
/GPIO23: U3.35 (GPIO23), U4.6 (INA)
/GPIO24: Q3.1 (G), U3.36 (GPIO24)
/GPIO25: Q5.1 (G), U3.37 (GPIO25)
/GPIO26: Q2.1 (G), U3.38 (GPIO26_ADC0)
/GPIO27: Q4.1 (G), U3.39 (GPIO27_ADC1)
/MOTOR_OUT_A: J19.1, R12.2, U4.4 (OUTA)
/MOTOR_OUT_B: J20.1, R14.2, U4.5 (OUTB)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D2.4 (-), D3.1 (K), J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J21.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R2.1, R3.1, R9.1, R13.1, R15.1, SW1.2, U1.2 (GND), U1.4 (GND), U2.4 (GND), U3.19 (TESTEN), U3.57 (GND), U4.1 (GND), U4.9 (GND), Y1.2, Y1.4
unnamed: C4.1, R5.2, Y1.1
unnamed: D3.2 (A), R10.1
unnamed: D2.1, J1.1, R8.2
unnamed: D2.2, J2.1
unnamed: J3.A5 (CC1), R2.2
unnamed: J3.B5 (CC2), R3.2
unnamed: J3.A6 (D+), J3.B6 (D+), R6.2
unnamed: J3.A7 (D-), J3.B7 (D-), R7.2
unnamed: J5.1, U3.26 (RUN)
unnamed: J6.1, U3.24 (SWCLK)
unnamed: J7.1, U3.25 (SWD)
unnamed: J8.1, U3.2 (GPIO0)
unnamed: J9.1, U3.3 (GPIO1)
unnamed: J10.1, U3.4 (GPIO2)
unnamed: J11.1, U3.5 (GPIO3)
unnamed: J12.1, U3.6 (GPIO4)
unnamed: J13.1, U3.7 (GPIO5)
unnamed: J14.1, Q3.3 (D)
unnamed: J15.1, Q5.3 (D)
unnamed: J16.1, Q2.3 (D)
unnamed: J17.1, Q4.3 (D)
unnamed: Q1.1 (G), R8.1, R9.2
unnamed: R4.2, SW1.1
unnamed: U2.6 (CLK), U3.52 (QSPI_SCLK)
unnamed: U2.5 (DI(IO0)), U3.53 (QSPI_SD0)
unnamed: U2.2 (DO(IO1)), U3.55 (QSPI_SD1)
unnamed: U2.3 (IO2), U3.54 (QSPI_SD2)
unnamed: U2.7 (IO3), U3.51 (QSPI_SD3)
unnamed: R1.1, R4.1, U2.1 (~CS), U3.56 (QSPI_SS)
unnamed: C13.1, R11.2, U3.43 (ADC_AVDD)
unnamed: R10.2, U3.15 (GPIO12)
unnamed: R7.1, U3.46 (USB_DM)
unnamed: R6.1, U3.47 (USB_DP)
unnamed: C1.1, U3.20 (XIN), Y1.3
unnamed: R5.1, U3.21 (XOUT)
VBUS: D1.2 (A), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
VDC: C5.1, C17.1, D1.1 (K), D2.3 (+), J18.1, U1.1 (VIN), U4.3 (VM)

Notes on the sheet:
Gates are pulled down using RP2040 pull-down resistors
Motor Driver
GPIO21 is pulled up internally in RP2040
Aux Outputs
C8/C9 should be close to pin 45/44
USB
Oscillator
Low-pass filter for ADC reference voltage f_c​ ≈ 79.6Hz
Flash
Input Stage

Board: 4 copper layers, 25.0 x 20.0 mm, 68 parts (22 on the bottom side), 51 nets.

## KiCad design KiCad/Rev_0_3/RP2040-Decoder.kicad_pcb

Parts:
C1, C2, C5, C6, C14: 10u; C_0603_1608Metric
C3, C4, C7, C8, C9, C10, C11, C12, C13, C15: 100n; C_0603_1608Metric
C16, C17: 10p; C_0603_1608Metric
D1: KMB24F; TO-269AA
J1: T0; TestPoint_Pad_D2.0mm
J2: T1; TestPoint_Pad_D2.0mm
J3, J8: 0; TestPoint_Pad_D2.0mm
J4, J9: 1; TestPoint_Pad_D2.0mm
J5, J10: 2; TestPoint_Pad_D2.0mm
J6, J11: 3; TestPoint_Pad_D2.0mm
J7: +3V3; TestPoint_Pad_D2.0mm
J12: 4; TestPoint_Pad_D2.0mm
J13: 5; TestPoint_Pad_D2.0mm
J14: +V; TestPoint_Pad_D2.0mm
J15: M_OUT_B; TestPoint_Pad_D2.0mm
J16: M_OUT_A; TestPoint_Pad_D2.0mm
J17: GND; TestPoint_Pad_D2.0mm
J18: SWCLK; TestPoint_Pad_D2.0mm
J19: SWDIO; TestPoint_Pad_D2.0mm
J20: RUN; TestPoint_Pad_D2.0mm
Q1, Q2, Q3, Q4, Q5: T2N7002BK; SOT-23
R1, R2, R5, R6: 6k8; R_0603_1608Metric
R3: 200; R_0603_1608Metric
R4: DNF; R_0603_1608Metric
R7, R8, R9: 1k; R_0603_1608Metric
U1: HT7533S; SOT-23
U2: BDR6133; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias
U3: W25Q64JVSSIQ; SOIC-8_5.23x5.23mm_P1.27mm
U4: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V1: C3.1, C4.1, C5.1, U4.23 (DVDD), U4.45 (VREG_VOUT), U4.50 (DVDD)
+3V3: C1.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, J7.1, R3.1, R4.2, U1.2 (VOUT), U2.2 (VCC), U3.8 (VCC), U4.1 (IOVDD), U4.10 (IOVDD), U4.22 (IOVDD), U4.33 (IOVDD), U4.42 (IOVDD), U4.44 (VREG_IN), U4.48 (USB_VDD), U4.49 (IOVDD)
+V: C2.1, D1.3 (+), J14.1, U1.3 (VIN), U2.3 (VM)
/ADC_EMF_A: R5.1, R7.2, U4.40 (GPIO28_ADC2)
/ADC_EMF_B: R6.1, R8.2, U4.41 (GPIO29_ADC3)
/GPIO21: Q1.3 (D), U4.32 (GPIO21)
/GPIO22: U2.7 (INB), U4.34 (GPIO22)
/GPIO23: U2.6 (INA), U4.35 (GPIO23)
/GPIO24: Q2.1 (G), U4.36 (GPIO24)
/GPIO25: Q3.1 (G), U4.37 (GPIO25)
/GPIO26: Q4.1 (G), U4.38 (GPIO26_ADC0)
/GPIO27: Q5.1 (G), U4.39 (GPIO27_ADC1)
/MOTOR_OUT_A: J15.1, R5.2, U2.4 (OUTA)
/MOTOR_OUT_B: J16.1, R6.2, U2.5 (OUTB)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.4 (-), J17.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R2.1, R7.1, R8.1, U1.1 (GND), U2.1 (GND), U2.9 (GND), U3.4 (GND), U4.19 (TESTEN), U4.57 (GND), Y1.2, Y1.4
unnamed: C14.1, R3.2, U4.43 (ADC_AVDD)
unnamed: D1.1, J1.1, R1.2
unnamed: D1.2, J2.1
unnamed: J3.1, Q2.3 (D)
unnamed: J4.1, Q3.3 (D)
unnamed: J5.1, Q4.3 (D)
unnamed: J6.1, Q5.3 (D)
unnamed: J8.1, U4.2 (GPIO0)
unnamed: J9.1, U4.3 (GPIO1)
unnamed: J10.1, U4.4 (GPIO2)
unnamed: J11.1, U4.5 (GPIO3)
unnamed: J12.1, U4.6 (GPIO4)
unnamed: J13.1, U4.7 (GPIO5)
unnamed: J18.1, U4.24 (SWCLK)
unnamed: J19.1, U4.25 (SWD)
unnamed: J20.1, U4.26 (RUN)
unnamed: Q1.1 (G), R1.1, R2.2
unnamed: R4.1, U3.1 (~CS), U4.56 (QSPI_SS)
unnamed: C17.1, R9.2, Y1.1
unnamed: U3.2 (DO(IO1)), U4.55 (QSPI_SD1)
unnamed: U3.3 (IO2), U4.54 (QSPI_SD2)
unnamed: U3.5 (DI(IO0)), U4.53 (QSPI_SD0)
unnamed: U3.6 (CLK), U4.52 (QSPI_SCLK)
unnamed: U3.7 (IO3), U4.51 (QSPI_SD3)
unnamed: C16.1, U4.20 (XIN), Y1.3
unnamed: R9.1, U4.21 (XOUT)

Notes on the sheet:
Gates are pulled down using RP2040 pull-down resistors
Motor Driver
GPIO21 is pulled up internally in RP2040
Aux Outputs
Crystal Oscillator
C5/C6 should be close to pin 45/44
Flash Memory
Input Stage

Board: 2 copper layers, 25.0 x 20.0 mm, 57 parts (20 on the bottom side), 41 nets.

## KiCad design KiCad/v0.2/RP2040_minimal_Decoder.kicad_pcb

Board: 2 copper layers, 43.2 x 50.8 mm, 63 parts (0 on the bottom side), 41 nets.

Parts:
C1, C4, C17: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 27p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7, C9, C11, C12, C13, C14, C15, C16: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C10: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: KMB24F; TO-269AA
H1, H2, H3, H5, H6: MountingHole; MountingHole_2.7mm_M2.5
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J5: T0; TestPoint_Plated_Hole_D2.0mm
J6: T1; TestPoint_Plated_Hole_D2.0mm
J7: +3V3; TestPoint_Pad_D1.5mm
J11: +V; TestPoint_Pad_D1.5mm
J12: M_OUT_B; TestPoint_Pad_D1.5mm
J13: M_OUT_A; TestPoint_Pad_D1.5mm
J14: GND; TestPoint_Pad_D1.5mm
J15: 0; TestPoint_Pad_D1.5mm
J16: 1; TestPoint_Pad_D1.5mm
J17: 2; TestPoint_Pad_D1.5mm
J18: 3; TestPoint_Pad_D1.5mm
J19: 4; TestPoint_Pad_D1.5mm
J20: 5; TestPoint_Pad_D1.5mm
J21: SWCLK; TestPoint_Pad_D1.5mm
J22: SWDIO; TestPoint_Pad_D1.5mm
J23: RUN; TestPoint_Pad_D1.5mm
Q1, Q2, Q3, Q4, Q5: T2N7002BK; SOT-23
R1, R5, R9, R11: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: DNF; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R8, R10: 6k8; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP2, TP3, TP4: 0; TestPoint_Pad_D1.5mm
U1: NCP1117-3.3_SOT223; SOT-23
U2: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U3: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm_BigThermalVias
U4: BDR6133; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_BigThermalVias
Y1: ABLS-12.000MHZ-B4-T; Crystal_SMD_HC49-SD

Connections:
+1V1: C6.1, C7.1, C8.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3V3: C1.1, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, J7.1, R2.1, U1.2 (VOUT), U2.8 (VCC), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.2 (VCC)
/GPIO0: J15.1, U3.2 (GPIO0)
/GPIO1: J16.1, U3.4 (GPIO2)
/GPIO2: J17.1, U3.5 (GPIO3)
/GPIO3: J18.1, U3.7 (GPIO5)
/GPIO4: J19.1, U3.15 (GPIO12)
/GPIO5: J20.1, U3.17 (GPIO14)
/GPIO21: Q1.3 (D), U3.37 (GPIO25)
/GPIO22: U3.38 (GPIO26_ADC0), U4.7 (INB)
/GPIO23: U3.39 (GPIO27_ADC1), U4.6 (INA)
/GPIO24: Q2.1 (G), U3.28 (GPIO17)
/GPIO25: Q3.1 (G), U3.29 (GPIO18)
/GPIO26: Q4.1 (G), U3.31 (GPIO20)
/GPIO27: Q5.1 (G), U3.34 (GPIO22)
/GPIO28_ADC2: R8.1, R9.2, U3.41 (GPIO29_ADC3)
/GPIO29_ADC3: R10.1, R11.2, U3.40 (GPIO28_ADC2)
/MOTOR_OUT_A: J12.1, R8.2, U4.4 (OUTA)
/MOTOR_OUT_B: J13.1, R10.2, U4.5 (OUTB)
/QSPI_SCLK: U2.6 (CLK), U3.52 (QSPI_SCLK)
/QSPI_SD0: U2.5 (DI(IO0)), U3.53 (QSPI_SD0)
/QSPI_SD1: U2.2 (DO(IO1)), U3.55 (QSPI_SD1)
/QSPI_SD2: U2.3 (IO2), U3.54 (QSPI_SD2)
/QSPI_SD3: U2.7 (IO3), U3.51 (QSPI_SD3)
/QSPI_SS: R1.1, R2.2, U2.1 (~CS), U3.56 (QSPI_SS)
/RUN: J23.1, U3.26 (RUN)
/SWCLK: J21.1, U3.24 (SWCLK)
/SWD: J22.1, U3.25 (SWD)
/XIN: C2.1, U3.20 (XIN), Y1.1
/XOUT: R5.1, U3.21 (XOUT)
/~USB_BOOT: J2.1, R1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.4 (-), J2.2, J14.1, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R7.1, R9.1, R11.1, U1.1 (GND), U2.4 (GND), U3.19 (TESTEN), U3.57 (GND), U4.1 (GND), U4.9 (GND)
unnamed: C3.1, R5.2, Y1.2
unnamed: D1.1, J5.1, R6.2
unnamed: D1.2, J6.1
unnamed: Q1.1 (G), R6.1, R7.2
unnamed: Q2.3 (D), TP1.1
unnamed: Q3.3 (D), TP2.1
unnamed: Q4.3 (D), TP3.1
unnamed: Q5.3 (D), TP4.1
VCC: C4.1, D1.3 (+), J11.1, U1.3 (VIN), U4.3 (VM)

## Commit log (part)

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2021-08-22 basispaket erkennen
2021-08-22 SIZE angepasst
2021-08-23 Revert "fix"
    This reverts commit 1e874c57495768e73a0e6d763d8bc83ff1a74c70.
2021-08-25 error detection + address & command evaluation
2021-08-27 function evaluation & CV & ...
2021-08-28 functions supported
2021-08-28 unnecessary functions removed & improved names
2021-08-29 Idle Package, Broadcast Package, small improvements
2021-09-02 Multicore IRQ + Timer for speed control
2021-09-03 PWM-Period adjustable, Vmin Vmax implemented, fixed alarm_callback, fixed FIFO IRQ
2021-09-19 Removede FIFO Irq, Addded function for measuring and controlling motor speed
2021-09-24 Updated CV_ARRAY, added save to Flash function, changed various small things
2021-09-27 Implemented Basic Programming features, changed speed control (speed_helper function with timed interrupt)
2021-09-30 changed init_speed_helper function & implemented a function to calculate end_v_emf_target
2021-11-13 Create LICENSE
2022-01-03 fixed acknowledge bit/byte read routine, many small fixes and improvements
2022-01-04 mainly changes in ACK, CV read/write, they should be reliable now (Core1 shutdown during read & write Acknowledge due to conflict of PWM functions)
2022-01-06 - renamed multicore.c to decoder.c and header files respectively - several changes to pid_control and speed_helper - measurements are now being "filtered" (x smallest and y biggest values will be dis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
2022-01-09 - divided decoder.c in core0.c & core1.c - improvements on set_outputs()
2022-01-27 - Correction for Zener Diode Voltage - Changes to Header Files
2022-01-27 Rename Input.svg to svg/Input.svg
2022-01-27 Rename Motor_Driver.svg to svg/Motor_Driver.svg
2022-01-29 Changed directories
2022-01-29 git commit -a
2022-01-30 PCB and Schematic
2022-01-31 -changes to gitignore regarding KiCad files -changes to svg Files & Schematic ( Missing Net (GPIO) @ Input Stage)
2022-01-31 Deleted unnecessary Files (KiCad)
2022-02-07 removed 47k resistor
2022-02-16 - Changes to sorting in measure() function - Changes to Zener Voltage Correction / measure now returns value in volts - Changes to Motor control - Resistor values changed - Created BOM
2022-02-16 -Added Multiplier to lengthen XOSC startup delay
2022-02-23 - implemented linear approximation for pwm duty cycle offset (feed forward) - changed pid params and variables in measure() from float to integers - implemented Motor PWM Frequency CV - improved ackn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
2022-02-28 Finished Board
2022-03-01 small changes to schematic and update to docs/svg
2022-03-01 updated svg
2022-03-02 -updated docs/png
2022-03-02 readme update & docs/png update (PCB Front png)
2022-03-05 -updated readme, -modified F0-F31 handling, - implemented pwm for F0-F31
2022-03-06 - changes to ADC offset adjustment; - changes to output set function; - cv_setup_check() now waits for core1 to launch also after programming
2022-03-12 - remove m_pwm_offset_adjustment; - offset now adjusted in pid_control loop; - pid sampling time depends on speed step; - speed table implemented & and init function;
2022-07-18 Change to Pin assignements in shared.h
2022-07-28 - Reduced amount of global variables. Many variables are now initialized in main() and core1_entry() respectively and then passed as pointer. - Updates in speed steps are passed via multicore fifo. -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
2022-08-01 - added shared.c file containing functions that can be accessed from both cores - revised CV programming especially writing - Core 1 is only started when valid package with correct address is receive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
2022-08-01 - Updated svg files (transparent bg)
2022-08-02 - Added long address svg - Direction is now preserved on packet timeout - Address > 127 can no longer be written to flash as it is not valid
2022-08-03 - Minor changes to variable names, comments & formatting - Removed obsolete parameter previously used in program_mode - Added correction constant regarding base pwm measurement - Revised GPIO definit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
2022-08-06 - added files for documentation - fixed undesired behaviour for direction change while decelerating - adjusted default value for CV_54 & CV_55
2023-01-09 fix writing CV_1 - the default case was missing
2023-02-22 working on PCB
    looking to mimic RPi's own minimal PCB
2023-02-28 moved current to v0.1, added new files to v.02
2023-03-01 cleaning up PCB
2023-03-02 restore v0.1
2023-04-27 more debug output
2023-05-08 more debug printfs, disabled function usage of gpio0/1, disabled usb interface to save some 25kb in the firmware image
2023-05-12 disable logging by default, added comments how to enable it and what are the consequences
2023-05-27 remove ALL logging if not enabled
2023-10-15 fixed wrong parameter in measure() function call
2023-12-04 created USB and non-USB folders; added USB schematic
2023-12-04 Changes to schematic, Created PCB
2023-12-05 added pcb constraints, changed designators, updated footprints and 3d-models, created board outline
2023-12-20 PCB Routing
2023-12-23 always append a new line to log
2023-12-26 Fix missing Bitmask in F0-F4 function evaluation, Handle NULL-pointer in get_direction(), CMakelists.txt disable optimizing, Upload CLion config
2023-12-30 Revert changes to LOG macro
2023-12-30 Completly remove .idea files and update .gitignore accordingly
2023-12-31 remove some warnings
2023-12-31 make more variables const
2024-01-01 Reformatting and renaming some functions; replaced get_direction() with get_direction_of_speed_step() in order to simplify handling of direction; additional explanation comment in CV.h; add doxygen c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
2024-01-02 Simplify get_speed_step_table_index_of_speed_step(); Removed unnecessary parameter from adjust_pwm_level function; Removed some redundant else statements and redundant "== true" from some expressions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
2024-01-02 Create doxygen-gh-pages.yml
    Create doxygen docs and deploy them
2024-01-02 Change Doxyfile paths to relative paths
2024-01-02 deploy: 461f65c88d2d9565a6696611b9192588f779d5f7
2024-01-02 deploy: b5b5de89ddcc71e7f3db6a35c9dfa22d592c628f
2024-01-02 Update Doxyfile
2024-01-03 Replace '≙' with '='
2024-01-03 deploy: 9b8906f47676f123410d379b2825a7816ec99204
2024-01-04 Copy code from flash to ram in order to not use XIP allowing writing to flash memory while both cores are running; Motor control now operates with two states/modes; Extended Default CV Range to 1024 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
2024-01-09 remove measure_base_pwm; add comments
2024-01-09 Add note regarding U1 / PJ75AL33SA LDO / Issue 23 to schematic; Update KiCad Project to version 7; Change C16 and C17 to 10pF
2024-11-24 New 4-Layer Board with USB; Update gitignore; Change Speed Table Comment;
2024-11-24 Add LCSC Part numbers
2024-11-25 Moving some components on the schematic
2024-11-25 add auto generate .svg python scripts
2024-11-25 modify gitignore
2024-11-26 fix file extension and pcb path
2024-11-26 Add rendered PCB images
2024-11-26 Deploy PCB images to gh-pages-dev
2024-11-26 deploy: babe18c758361865d80c651e39725ad68aadc74d
2024-11-26 deploy: 70846f5336f95d9acf6bbbd12dbd2692d78cf12b
2024-11-26 deploy: 3f7f092b2c84c03ab5dc2a53344a9244f9f1db1a
2024-11-26 deploy: 12b45b9da3093d0087d9c7c4d8792b1875d5c1b6
2024-11-26 deploy: 36119ff6f58f7d947106f630da9a801363079a42
2024-11-26 cleanup old html files, they are in /html/ now
2024-11-27 Update documentation system with doxygen/breathe/sphinx
2024-11-27 Update docs
2024-11-27 update docs workflow
2024-11-27 update workflow
2024-11-27 deploy: bce1405a60c5a706f76a459c08215d32b05c3838
2024-12-22 Moved all software related files to Software folder; Now using flash safe execution functions of pico_flash (pico SDK) lib; Added error handling; Added RP2040-Decoder-board.h definition; Adapted CMak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
2024-12-22 deploy: 7b1d5ed152f356dbf5090164f35dc1678e0361b1
2024-12-22 Expanded on stdio logging functionality, also configuration of logging is now entirely in CMakeLists.txt for convenience, also warns now for logging configurations that make no sense; Clarification i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
2024-12-23 Update documentation and docs folder structure; Add abs() function using bit operators; Remove LED pin definition from legacy board definition as it does not have an LED; Implement watchdog timer; Ad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
2024-12-23 deploy: 7d2c80574a1ea3c012d9576170db601abd3da763
2024-12-25 deploy: acdbf3cffe9f3456902e11088aa95b2c8b12f92a
2024-12-29 - Updated CMakeLists.txt and board config .h files - Refactored core0.c to most functions are now static functions. - Introduced new structures (`dcc_packet_t` and `dcc_ring_buffer_t`) for DCC packet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
2024-12-29 deploy: d970170795b4edca2aba781e8100b586d71710e1
2024-12-30 Update CMake configuration, move post-build program size check to seperate post_build.cmake script
2024-12-30 deploy: 97b92fd9d8a1f74af5be8fa9a777c3a83f11c8bf
2024-12-30 deploy: 0462d3f6b7e8f4735dbe71ad797b200aa8d0dad5
2024-12-30 Update pcb_render.yml
    Fix wrong folder due to new subfolder for revisions
2024-12-31 Change C18 to be 0603 - 25V and rotate on PCB for easier soldering; Small logging changes; Speed step enums are actually used now for better clarity; Introduced cv_setup_check_done and flash_safe_exe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
2024-12-31 deploy: 7e1c079e10f4a254ce137026e0d08cc3ff8fe35f
2024-12-31 Removed images as they are automatically deployed to gh-pages branch
2024-12-31 Remove true expression used for debugging
2024-12-31 deploy: e648e5dfa2e3fab7475504b7be08e16761a44335
2025-01-02 deploy: 91eb160833631fca62775eb5ea40b4ab41b97bfe
2025-01-02 deploy: a7531be0e6556a9c78e1ba02cc554c03c0a21e32
2025-01-02 deploy: 7ab3f74cba0184f5fcf35c8b2c88aa7aa0380f75
2025-01-02 deploy: 17c67b5ba82eddd00e7a255e5c7e61cdc8c44a05
2025-01-02 deploy: ad888dd4a0edb70464763399c03384377a57075b
2025-01-02 deploy: 21bee73f01df4592d2f59b4c3fbc71b56f485040
2025-01-02 deploy: be49c1b43f8b104742ace27fb2b0f1308752428a
2025-01-02 deploy: d0e7406627e62d0312423799e7d2f8375b2f58e3
2025-01-02 deploy: 738575263fff2c0d81ad442e6532e6fe5c0d6e39
2025-01-02 Update workflow files
2025-01-02 Update workflows
2025-01-02 Update release/prerelease workflow
2025-01-02 Update fab_outputs wf
2025-01-03 Replaced solder bridge with tactile button; Fixed Footprint Rotation in position file; Fixed .gitignore for production outputs
2025-01-03 deploy: 87e4aff24fdc9f5f6f19aae05b96c46349e072a0
2025-01-03 remove fab_outputs.yml moving fabrication output generation to prerelease.yml and release.yml
2025-01-04 Update Sphinx documentation
2025-01-04 Update documentation doxygen comments
2025-01-04 deploy: cc48cca7791772d11b2e878a4e65c2ddb43d211f
2025-01-04 deploy: 93455218e880851d898d2068e5cb3ee4611cf355
2025-01-05 deploy: a2b1233c4e932a1f3c195c2e9cab67be13ca66a1
2025-01-05 Update PCB render workflow
2025-01-05 deploy: fcb66fc92c16b6b217cd61fa640a71f5e8449071
2025-01-05 deploy: 3348e3a6a0f6eefa66e28dc18b732c4f882cc41d
2025-01-31 Update RP2040-Decoder.kicad_pcb
    This is my first time commenting.
    There are 6 locations with 0.2mm drill holes.
    I think 0.3mm is sufficient for these.
    This reduces manufacturing costs.
    Thank you for your consideration.
2025-04-14 deploy: d10af5d8bd4994a789b08e1c67dcd7f520361435
2025-04-14 Update getting_started.rst
    Fix some minor spelling mistakes
2025-04-14 deploy: c31c062f04ae2ae16cf25db2143c2665d107d91c
2025-04-14 Change PCB to rev 1.1 to reflect changes in PR35 from @HMX-1972
2025-04-14 Rename Rev_1_0 KiCad folder to USB and Rev_0_3 folder to Legacy
2025-04-14 Rename Rev_1_0 to USB HW Rev and Rev_0_3 to Legacy HW Rev in workflows and documentation also rename corresponding folders
2025-04-14 deploy: e091fc96d365365d19528d6fe80757ecbb7edd5d
2025-04-15 Update README and add Revision attribute to PCB which updates Rev x.x silkscreen on the back side;
2025-04-15 deploy: b968c6d31d7b14b836f55db48922570b65f96b7c
2025-04-27 deploy: 24c01a0d7c501d0c46238b4169902573fb0efaa1
2025-10-27 docs: Add detailed motor control feature descriptions
    Adds in-detail descriptions of the features used in the motor control to the documentation.
    This includes:
    - Speed Table Initialization
    - Startup Controller logic
    - Gain Scheduling (`get_kp` function)
    - Speed Helper (acceleration/deceleration)
2025-11-03 feat: Add and initialize common CV registers
    This commit adds the most common CV registers to the project and initializes them with standard default values as specified by the NMRA. This provides a more robust and standards-compliant default co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
    The following changes were made:
    - Added and initialized CVs for consist addressing, function control, and other common features.
    - Updated existing CVs to align with NMRA standards where they differed.
    - Improved readability by using decimal values for CVs and adding descriptive comments.
2025-11-29 deploy: b71fd008df746e6bae44387512195aa0a40a0b8b
2025-12-16 Define CVs
2025-12-17 deploy: 1e9fb3ed9f8d8f11b4b4e3b78946b2ae018dfd19
